# Keil uVision project zhinengjiaju.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: zhinengjiaju +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51 lcd12864.c DHT11.c UART.c timer0.c
